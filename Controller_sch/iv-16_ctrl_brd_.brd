# Repository fenr1r/IV-16_clock

File README.md:

# IV-16_clock

for more information please refer to my blog:

- https://vita-brevis.hatenablog.com/entry/2025/09/03/032029
- https://vita-brevis.hatenablog.com/entry/2025/12/10/101918

### Contents

- Controller_program : AVR ATmega328P program (AtmelStudio)
- Controller_sch : schematic and gerber files (Eagle)
- Display_sch : schematic and gerber files (Eagle)
- Side_panel_pcb : drawing of the side panel (KiCad)

### Used libraries

This project uses library described below:

- Sovichea's avr-i2c-library :  Copyright (c) 2019 Sovichea Tep (twimaster.cpp & twimaster.hpp)

## EAGLE design Controller_sch/iv-16_ctrl_brd_.brd

Parts:
BAT1: CR2032; CH29-2032LF
C1, C6, C7, C8, C12: 0.1u(1608); C0603
C2, C9, C11: 0.1u 16V X7R; C0603
C3, C5: 1u 16V X7R; C0603
C4: 10uF; E2,5-7
CN1: MJ-179PH; DCJACK_2MM_THIN_18742
CN2: S2B-XH-A(LF)(SN); B2B-XH-A
CN3: XN_8; CON8
D1: 1N4148DO35-7; DO35-7
D2, D3: 1S4_DO35-7; 0309V
F1: 1.25A; PTC
FB1, FB2: FB; 0603
H1, H2, H3, H4: MOUNT-PAD-ROUND3.2; 3,2-PAD
IC1: RTC-8564NB; RTC-8564_MODULE
IC2: 74AC14D; SO14
IC3: ATMEGA8-16PU; DIL28-3
IC4: LM35DZ; TO92-LINE
JP1: PINHEAD-3; 1X03/90
JP2: PINHEAD-2; JP1
JP3: PINHEAD-2_SMD; 1X02SMD
LED1, LED2, LED3, LED4, LED5: TLG1002; CHIPLED_0805
R1, R2, R3, R6: 10k 1/4W; R0805
R4, R7: 100 1/4W; R0805
R5, R13, R15, R16, R17: 510; 0207/10
R8, R9, R10, R11: 220; R0603
R12, R14: 2.2k; 0309V
S1, S2, S3: Tactile Switch; B3F-10XX
SJ1, SJ2, SJ3, SJ4, SJ5, SJ6, SJ7, SJ8, SJ9, SJ10, SJ11: SJ
SV1: BOX_HEADER_2x3; ML6
SW1: SS-12SDP2
SW2: 2MS1-T1-B4-M7-Q-E-S
U1, U2: CERALOCK 10MHz; CERALOCK
U3: ATMEGA328P-AU; TQFP32-08

Connections:
#RESET: C2.1, D1.A, IC3.1 (PC6(/RESET)), R2.1, S1.1 (S), S1.2 (S1), SV1.5, U3.29 (PC6(!RESET!/PCINT14))
AVR_RXD: IC3.2 (PD0(RXD)), SJ10.2, U3.30 (PD0(RXD/PCINT16))
AVR_TXD: IC3.3 (PD1(TXD)), SJ11.2, U3.31 (PD1(TXD/PCINT17))
GND: BAT1.-, C1.2, C2.2, C3.2, C4.-, C5.2, C6.2, C7.2, C8.2, C9.1, C11.1, C12.1, CN1.GND, CN1.GNDBREAK, CN2.1, CN3.P$1 (1), CN3.P$6 (6), H1.B3,2, H2.B3,2, H3.B3,2, H4.B3,2, IC1.4 (VSS), IC2.1 (I), IC2.3 (I), IC2.5 (I), IC2.7 (GND), IC2.11 (I), IC3.8 (GND), IC3.22 (GND), IC4.1 (GND), JP1.1, LED1.C, LED2.C, LED3.C, LED4.C, LED5.C, S1.3, S1.4 (P1), S2.3, S2.4 (P1), S3.3, S3.4 (P1), SV1.6, SW1.1 (O), U1.2, U2.2, U3.3 (GND), U3.5 (GND1), U3.21 (GND2)
ISP_MISO: IC3.18 (PB4(MISO)), SV1.1, U3.16 (PB4(PCINT4/MISO))
IV16_#OE: IC3.16 (PB2(SS/OC1B)), R11.1, U3.14 (PB2(PCINT2/!SS!/OC1B))
IV16_#SLAT: IC3.14 (PB0(ICP)), R8.1, U3.13 (PB1(PCINT1/OC1A))
IV16_ISP_SCK: IC3.19 (PB5(SCK)), R9.1, SV1.3, U3.17 (PB5(SCK/PCINT5))
IV16_SIN_ISP_MOSI: IC3.17 (PB3(MOSI/OC2)), R10.1, SV1.4, U3.15 (PB3(PCINT3/OC2A/MOSI))
LED1: IC3.5 (PD3(INT1)), R13.2, U3.12 (PB0(PCINT0/CLKO/ICP1))
LED2: IC3.6 (PD4(XCK/T0)), R15.2, U3.11 (PD7(PCINT23/AIN1))
LED3: IC3.11 (PD5(T1)), R16.2, U3.10 (PD6(PCINT22/OC0A/AIN0))
LED4: IC3.12 (PD6(AIN0)), R17.2, U3.9 (PD5(PCINT21/OC0B/T1))
LM35: IC3.23 (PC0(ADC0)), SJ7.1, U3.23 (PC0(ADC0/PCINT8))
unnamed: D2.2 (C), D3.2 (C), IC1.8 (VDD)
unnamed: JP1.3, SJ11.1
unnamed: JP1.2, SJ10.1
unnamed: IC2.12 (O), SJ5.2
unnamed: R6.1, R7.1, S3.1 (S), S3.2 (S1)
unnamed: C5.1, IC2.13 (I), R7.2
unnamed: F1.P$2 (2), SW2.2 (2COMM)
unnamed: IC2.8 (O), SJ2.2
unnamed: LED3.A, R15.1
unnamed: IC3.10 (PB7(XTAL2/TOSC2)), U2.3
unnamed: LED4.A, R16.1
unnamed: IC4.2 (OUT), SJ7.2
unnamed: LED5.A, R17.1
unnamed: SJ3.2, SV1.2
unnamed: C9.2, IC3.21 (AREF)
unnamed: SJ1.1, SW1.2
unnamed: C7.1, FB2.2, IC3.20 (AVCC)
unnamed: C6.1, FB1.2, U3.18 (AVCC)
unnamed: C3.1, IC2.9 (I), R4.2
unnamed: BAT1.+@1 (+), BAT1.+@2 (+), D3.1 (A)
unnamed: R1.1, SW1.3 (S)
unnamed: C11.2, U3.20 (AREF)
unnamed: CN1.PWR, CN2.2, F1.P$1 (1)
unnamed: C8.1, FB1.1, JP3.2, U3.4 (VCC), U3.6 (VCC1)
unnamed: LED2.A, R13.1
unnamed: LED1.A, R5.1
unnamed: C12.2, FB2.1, IC3.7 (VCC), JP2.2
unnamed: CN3.P$2 (2), R8.2
unnamed: CN3.P$3 (3), R9.2
unnamed: CN3.P$4 (4), R10.2
unnamed: CN3.P$5 (5), R11.2
unnamed: R3.1, R4.1, S2.1 (S), S2.2 (S1)
unnamed: IC3.9 (PB6(XTAL1/TOSC1)), U2.1
RTC_1HZ_AVR: IC3.4 (PD2(INT0)), SJ6.1, U3.32 (PD2(INT0/PCINT18))
RTC_1HZ_INT: IC1.2 (CLKOUT), SJ6.2
RTC_SCL: IC1.6 (SCL), R14.1, SJ9.2
RTC_SCL_AVR: IC3.28 (PC5(ADC5/SCL)), SJ9.1, U3.28 (PC5(ADC5/SCL/PCINT13))
RTC_SDA: IC1.5 (SDA), R12.1, SJ8.2
RTC_SDA_AVR: IC3.27 (PC4(ADC4/SDA)), SJ8.1, U3.27 (PC4(ADC4/SDA/PCINT12))
SW_12/24: IC3.24 (PC1(ADC1)), SJ1.2, U3.24 (PC1(ADC1/PCINT9))
SW_CNT_UP: IC3.26 (PC3(ADC3)), SJ5.1, U3.26 (PC3(ADC3/PCINT11))
SW_COL_SEL: IC3.25 (PC2(ADC2)), SJ2.1, U3.25 (PC2(ADC2/PCINT10))
VCC_5V: C1.1, C4.+, CN3.P$7 (7), D1.C, D2.1 (A), IC2.14 (VCC), IC4.3 (VS+), JP2.1, JP3.1, R1.2, R2.2, R3.2, R5.2, R6.2, R12.2, R14.2, SJ3.1, SJ4.2, SW2.1
VTUBE: CN3.P$8 (8), SJ4.1
XTAL1: U1.1, U3.7 (PB6(PCINT6/XTAL1/TOSC1))
XTAL2: U1.3, U3.8 (PB7(PCINT7/XTAL2/TOSC2))

Notes on the sheet:
(2.1mm x 5.5mm DC-JACK)
SIDE-BASE, 2P, XH CON
connect
#INT0
UART
ピン配置を、秋月の「FT234X 超小型USBシリアル変換モジュール」に合わせる
GND TxD RxD
ジャンパ（USBシリアルモジュールからの給電）
+10mV/℃
電池ソケット：CH29-2032LF
BH-06SG

Board: 2 copper layers, 99.4 x 46.1 mm, 74 parts (5 on the bottom side), 60 nets.

## EAGLE design Display_sch/untitled.brd

Parts:
C1, C2, C3: 0.1; C2012
CN1: XN_8; CON8
H1, H2, H3, H4: MOUNT-PAD-ROUND3.2; 3,2-PAD
IC1, IC2, IC3: TC62D748CFG; TSSOP-24
J1, J2, J3, J4, J5, J6: J5MM; 05
R1, R3, R5: 680; 0309V
R2, R4, R6: 330; 3362P
SJ1, SJ2, SJ3, SJ4, SJ5, SJ6, SJ7, SJ8, SJ9, SJ10, SJ11, SJ12, SJ13: SJ
TUBE1, TUBE2, TUBE3, TUBE4, TUBE5, TUBE6: IV-16; IV-17_COMP

Connections:
#OE: CN1.P$5 (5), SJ1.2, SJ7.2, SJ11.2
#SLAT: CN1.P$2 (2), SJ4.2, SJ9.2, SJ13.2
GND: C1.2, C2.2, C3.2, CN1.P$1 (1), CN1.P$6 (6), H1.B3,2, H2.B3,2, H3.B3,2, H4.B3,2, IC1.1 (GND), IC2.1 (GND), IC3.1 (GND), R2.1, R4.1, R6.1
unnamed: IC1.22 (SOUT), SJ6.2
unnamed: IC1.14 (!OUT9), TUBE1.A
unnamed: IC1.11 (!OUT6), TUBE2.G
unnamed: IC1.16 (!OUT11), TUBE1.C
unnamed: IC1.17 (!OUT12), TUBE1.D
unnamed: IC1.18 (!OUT13), TUBE1.E
unnamed: IC1.19 (!OUT14), TUBE1.F
unnamed: IC2.6 (!OUT1), TUBE4.B
unnamed: IC2.7 (!OUT2), TUBE4.C
unnamed: IC2.9 (!OUT4), TUBE4.E
unnamed: IC2.8 (!OUT3), TUBE4.D
unnamed: IC2.10 (!OUT5), TUBE4.F
unnamed: IC2.11 (!OUT6), TUBE4.G
unnamed: IC2.14 (!OUT9), TUBE3.A
unnamed: IC3.6 (!OUT1), TUBE6.B
unnamed: IC2.15 (!OUT10), TUBE3.B
unnamed: IC3.7 (!OUT2), TUBE6.C
unnamed: IC2.17 (!OUT12), TUBE3.D
unnamed: IC3.8 (!OUT3), TUBE6.D
unnamed: IC2.19 (!OUT14), TUBE3.F
unnamed: IC3.10 (!OUT5), TUBE6.F
unnamed: IC2.5 (!OUT0), TUBE4.A
unnamed: IC3.11 (!OUT6), TUBE6.G
unnamed: IC3.9 (!OUT4), TUBE6.E
unnamed: IC3.14 (!OUT9), TUBE5.A
unnamed: IC3.16 (!OUT11), TUBE5.C
unnamed: IC3.18 (!OUT13), TUBE5.E
unnamed: IC3.5 (!OUT0), TUBE6.A
unnamed: IC3.15 (!OUT10), TUBE5.B
unnamed: IC2.2 (SIN), SJ6.1
unnamed: IC3.19 (!OUT14), TUBE5.F
unnamed: IC1.23 (REXT), R1.1
unnamed: IC2.23 (REXT), R3.1
unnamed: IC3.23 (REXT), R5.1
unnamed: IC3.17 (!OUT12), TUBE5.D
unnamed: R1.2, R2.2, R2.3
unnamed: IC2.22 (SOUT), SJ10.2
unnamed: IC3.2 (SIN), SJ10.1
unnamed: R3.2, R4.2, R4.3
unnamed: IC1.21 (!OE), SJ1.1
unnamed: IC1.3 (SCK), SJ2.1
unnamed: IC1.2 (SIN), SJ3.1
unnamed: IC1.4 (!SLAT), SJ4.1
unnamed: IC2.21 (!OE), SJ7.1
unnamed: IC2.3 (SCK), SJ8.1
unnamed: IC2.4 (!SLAT), SJ9.1
unnamed: IC3.21 (!OE), SJ11.1
unnamed: IC3.3 (SCK), SJ12.1
unnamed: IC1.15 (!OUT10), TUBE1.B
unnamed: IC3.4 (!SLAT), SJ13.1
unnamed: J1.1, TUBE1.COM
unnamed: J2.1, TUBE2.COM
unnamed: J3.1, TUBE3.COM
unnamed: J4.1, TUBE4.COM
unnamed: J5.1, TUBE5.COM
unnamed: J6.1, TUBE6.COM
unnamed: R5.2, R6.2, R6.3
unnamed: IC2.16 (!OUT11), TUBE3.C
unnamed: IC3.20 (!OUT15), TUBE5.G
unnamed: IC2.20 (!OUT15), TUBE3.G
unnamed: IC1.20 (!OUT15), TUBE1.G
unnamed: IC2.18 (!OUT13), TUBE3.E
unnamed: IC1.10 (!OUT5), TUBE2.F
unnamed: IC1.9 (!OUT4), TUBE2.E
unnamed: IC1.8 (!OUT3), TUBE2.D
unnamed: IC1.7 (!OUT2), TUBE2.C
unnamed: IC1.5 (!OUT0), TUBE2.A
unnamed: IC1.6 (!OUT1), TUBE2.B
SCK: CN1.P$3 (3), SJ2.2, SJ8.2, SJ12.2
SIN: CN1.P$4 (4), SJ3.2
VCC_5V: C1.1, C2.1, C3.1, CN1.P$7 (7), IC1.24 (VCC), IC2.24 (VCC), IC3.24 (VCC), SJ5.2
VTUBE: CN1.P$8 (8), J1.2, J2.2, J3.2, J4.2, J5.2, J6.2, SJ5.1

Board: 2 copper layers, 99.4 x 46.1 mm, 42 parts (0 on the bottom side), 75 nets.

## Code that names these connections

File Controller_program/GccApp1_Atmega328P/LED.hpp:

/*
 * LED.h
 *
 * Created: 2025/11/11 2:31:44
 *  Author: fenrir_
 */ 

// MEMO
// 
// LED1 : PB0
// LED2 : PD7
// LED3 : PD6
// LED4 : PD5

#ifndef LED_H_
#define LED_H_

#define BOOL int
#define TRUE 1
#define FALSE 0

void init_LEDs();
void clear_LEDs();
void set_LEDs();
void set_LEDs(const uint8_t);

void set_LED1(const BOOL);
void set_LED2(const BOOL);
void set_LED3(const BOOL);
void set_LED4(const BOOL);

void set_LED1();
void clear_LED1();
void set_LED2();
void clear_LED2();
void toggle_LED2();
void set_LED3();
void clear_LED3();
void toggle_LED3();
void set_LED4();
void clear_LED4();

#endif /* LED_H_ */

## Commit log

2025-12-10 Add side panel pcb files

Notices in the files:
parts and their libraries:
SparkFun-PowerIC: Licensing: CC v3.0 Share-Alike You are welcome to use this library for commercial purposes.
